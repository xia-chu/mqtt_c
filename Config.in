## Config.in
```kconfig
config AOS_APP_MQTT_C
    bool "mqtt_c"
    select AOS_COMP_NETMGR
    select AOS_COMP_CLI
    help
        mqtt_c Help

if AOS_APP_MQTT_C
endif
```
